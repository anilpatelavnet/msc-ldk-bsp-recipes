# Copyright (C) 2022 AVNET Embedded, MSC Technologies GmbH

RDEPENDS_${PN}_remove += " \ 
	eudev-hwdb \
	eudev \
	"
