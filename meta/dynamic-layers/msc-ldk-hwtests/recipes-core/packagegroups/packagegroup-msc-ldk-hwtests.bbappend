RDEPENDS_${PN}_remove += " \
        peak-linux-driver \
"

