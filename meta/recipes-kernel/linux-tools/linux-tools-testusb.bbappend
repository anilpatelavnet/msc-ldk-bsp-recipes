PR = "r3"

do_compile_prepend() {
    cd ${STAGING_KERNEL_DIR}/tools/usb/
}

do_install_prepend() {
    cd ${STAGING_KERNEL_DIR}/tools/usb/
}

